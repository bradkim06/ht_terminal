<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LoRa_AS923.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LoRa_SKT.ewp</path>
  </project>
  <batchBuild/>
</workspace>



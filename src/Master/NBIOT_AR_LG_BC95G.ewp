# IAR project NBIOT_AR_LG_BC95G.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5419A MSP430F5419A
  General.GStackSize2: 4096
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; NBIOT_LG_TYPE; NBIOT_MODEM_BC95G; AUX_REPEATER
  ICC430.newCCIncludePaths: SRC; SRC\app; SRC\dev; SRC\misc; SRC\osal; SRC\test; SRC\slave; SRC\modem\nbiot_lg; SRC\modem\nbiot_lg\uuid
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5419A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG; NBIOT_LG_TYPE; NBIOT_MODEM_BC95G; AUX_REPEATER
  ICC430.CCDiagSuppress: Pa050
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5419a_iotTerminal.xcl
  group APP
    SRC/app/: app.c main.c meter.c nfcProtocol.c rtcAlarm.c
  group DEV
    SRC/dev/: battery.c dataFlash.c flashDriver.c lcdDriver.c MSP430FlashUtil.c NFC_i2c.c RTCASMFunctions_IAR.s43 uart.c
  group MISC
    SRC/misc/: check_meter_misc.c crc.c
  group MODEM/NBIOT_LG
    SRC/modem/nbiot_lg/: message.c modem.c nbiotProcess.c nbiotResponse.c
  group MODEM/NBIOT_LG/UUID
    SRC/modem/nbiot_lg/uuid/: nbiot_lg_uuid_release.r43
  group OSAL
    SRC/osal/: osal.c osal_Timer.c Task_Mgr.c
  group SLAVE
    SRC/slave/: bsp.c bsp.h cc1200.c cc1200.h cc1200_reg_config.h cc120x_spi.c cc120x_spi.h hal_defs.h hal_spi_rf_trxeb.c hal_spi_rf_trxeb.h hal_types.h slaveAccess.c slaveAccess.h slaveMessage.h
  group TEST
    SRC/test/: mTest.c rfTest.c shell.c test.c

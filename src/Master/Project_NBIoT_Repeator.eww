<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NBIOT_AR_V150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NBIOT_AR_LG_V150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NBIOT_AR_BC95G.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NBIOT_AR_LG_BC95G.ewp</path>
  </project>
  <batchBuild/>
</workspace>

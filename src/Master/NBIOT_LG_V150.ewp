# IAR project NBIOT_LG_V150.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5419A MSP430F5419A
  General.GStackSize2: 4096
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; NBIOT_LG_TYPE; NBIOT_MODEM_TPB23
  ICC430.newCCIncludePaths: SRC; SRC\app; SRC\dev; SRC\misc; SRC\osal; SRC\test; SRC\modem\nbiot_lg; SRC\modem\nbiot_lg\uuid
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5419A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG; NBIOT_LG_TYPE; NBIOT_MODEM_TPB23
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group APP
    SRC/app/: app.c main.c meter.c nfcProtocol.c rtcAlarm.c
  group DEV
    SRC/dev/: battery.c flashDriver.c lcdDriver.c MSP430FlashUtil.c NFC_i2c.c RTCASMFunctions_IAR.s43 uart.c
  group MISC
    SRC/misc/: check_meter_misc.c crc.c
  group MODEM/NBIOT_LG
    SRC/modem/nbiot_lg/: message.c modem.c nbiotProcess.c nbiotResponse.c
  group MODEM/NBIOT_LG/UUID
    SRC/modem/nbiot_lg/uuid/: nbiot_lg_uuid_release.r43
  group OSAL
    SRC/osal/: osal.c osal_Timer.c Task_Mgr.c
  group TEST
    SRC/test/: mTest.c shell.c test.c

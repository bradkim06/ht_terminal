# IAR project LoRa_SKT_AR.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5419A MSP430F5419A
  General.GStackSize2: 4096
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; LORA_SKT_TYPE; AUX_REPEATER
  ICC430.newCCIncludePaths: SRC; SRC\app; SRC\dev; SRC\misc; SRC\osal; SRC\test; SRC\modem\lora_skt; SRC\slave
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5419A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG; LORA_SKT_TYPE; AUX_REPEATER
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group APP
    SRC/app/: app.c main.c meter.c nfcProtocol.c rtcAlarm.c
  group DEV
    SRC/dev/: battery.c flashDriver.c lcdDriver.c MSP430FlashUtil.c NFC_i2c.c RTCASMFunctions_IAR.s43 uart.c
  group MISC
    SRC/misc/: check_meter_misc.c crc.c
  group MODEM/LORA_SKT
    SRC/modem/lora_skt/: loraProcess.c loraResponse.c message.c modem.c
  group OSAL
    SRC/osal/: osal.c osal_Timer.c Task_Mgr.c
  group SLAVE
    SRC/slave/: bsp.c cc1200.c cc120x_spi.c hal_spi_rf_trxeb.c slaveAccess.c
  group TEST
    SRC/test/: mTest.c rfTest.c shell.c test.c

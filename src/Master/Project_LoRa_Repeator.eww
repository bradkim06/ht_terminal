<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LoRa_SKT_AR.ewp</path>
  </project>
</workspace>


